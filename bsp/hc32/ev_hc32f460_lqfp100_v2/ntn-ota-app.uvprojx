# Keil uVision project ntn-ota-app.uvprojx, settings and files
target ntn-ota-app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00020400,0x5b400) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000)  IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: ntn-ota-app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: RT_USING_ARMLIBC, __DEBUG, USE_DDL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, HC32F460, NTN_OTA_APP, VECT_TAB_OFFSET=0x00020400
  c include: .;applications;applications\segger_rtt;board;board\ports;board\config;board\config\usb_config;packages\hc32-f4-cmsis-latest\Include;packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f460\Include;packages\hc32-f4-series-latest\hc32f460\inc;..\..\..\include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\spi;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\fal\inc;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\components\net\utest;..\libraries\hc32_drivers;..\libraries\hc32_drivers\drv_flash;..\platform\fal;..\platform\sfud;..\tests;boot;build/ntn-ota
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\boot\ota_app.sct
  group Applications
    applications/: app_flash.c app_modbus.c app_telemetry.c pc_maint_core.c bt_identity.c ble_uart.c gnss_um220.c hw_power.c main.c ntn_ms150.c param_manager.c mcu_local_cmd.c raw_uplink.c loc2_report.c pc_rs232.c store_forward.c task_wdt.c xtal32_fcm.c
    boot/: ota_identity.c ota_app.c ota_flash.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_qspi.c drv_spi.c drv_usart.c drv_wdt.c
    ../libraries/hc32_drivers/drv_flash/: drv_flash_f4.c
  group Fal
    ../platform/fal/: fal_flash_sfud_nor.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
    ../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group HC32F460-LL
    packages/hc32-f4-series-latest/hc32f460/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_i2s.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_sram.c hc32_ll_utility.c hc32f460_ll_interrupts_share.c hc32_ll_usart.c hc32_ll_tmr0.c hc32_ll_i2c.c hc32_ll_spi.c hc32_ll_qspi.c hc32_ll_swdt.c hc32_ll_wdt.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f460/Source/: system_hc32f460.c
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f460/Source/ARM/: startup_hc32f460.s
  group SEGGER_RTT
    applications/segger_rtt/: SEGGER_RTT.c drv_rtt.c
  group Tests
    ../tests/: test_uart_v1.c test_qspi.c test_i2c.c test_wdt.c test_fal.c test_gpio.c
