# Keil uVision project flash.uvprojx, settings and files
target ALL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000)  IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: ntn-ota-l0.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: RT_USING_ARMLIBC, __DEBUG, USE_DDL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, HC32F460
  c include: .;applications;applications\segger_rtt;board;board\ports;board\config;board\config\usb_config;packages\hc32-f4-cmsis-latest\Include;packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f460\Include;packages\hc32-f4-series-latest\hc32f460\inc;..\..\..\include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\spi;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\fal\inc;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\components\net\utest;..\libraries\hc32_drivers;..\libraries\hc32_drivers\drv_flash;..\platform\fal;..\platform\sfud;..\tests
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
target BL1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: as above
  output: flash-bl1.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
target BL2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: as above
  output: flash-bl2.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: as above
  output: flash-primary.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
