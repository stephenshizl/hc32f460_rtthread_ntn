# Keil uVision project ntn-ota-bl1.uvprojx, settings and files
target ntn-ota-bl1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x4000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000)  IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: ntn-ota-bl1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: RT_USING_ARMLIBC, __DEBUG, USE_DDL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, HC32F460, NTN_OTA_BL1, VECT_TAB_OFFSET=0x00000000
  c misc: --preinclude boot/ota_icg.h
  c include: .;applications;applications\segger_rtt;board;board\ports;board\config;board\config\usb_config;packages\hc32-f4-cmsis-latest\Include;packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f460\Include;packages\hc32-f4-series-latest\hc32f460\inc;..\..\..\include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\spi;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\fal\inc;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\components\net\utest;..\libraries\hc32_drivers;..\libraries\hc32_drivers\drv_flash;..\platform\fal;..\platform\sfud;..\tests;boot;build/ntn-ota
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\boot\ota_bl1.sct
  group HC32F460-LL
    packages/hc32-f4-series-latest/hc32f460/src/: hc32_ll_clk.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_usart.c hc32_ll_swdt.c
  group Libraries
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f460/Source/: system_hc32f460.c
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f460/Source/ARM/: startup_hc32f460.s
  group BL1
    boot/: ota_bl1.c
    packages/hc32-f4-series-latest/hc32f460/src/: hc32_ll_hash.c
